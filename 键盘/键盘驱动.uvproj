# Keil uVision project 键盘驱动.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RB2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: 键盘驱动 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: keyboard_test.c key_board.c key_board.h key_board_cfg.h
    ../led显示字符/: led_display.c
