# Keil uVision project 蜂鸣器.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RB2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: 蜂鸣器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: alarm.c alarm.h alarm_cfg.h alarm_test.c
