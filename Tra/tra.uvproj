# Keil uVision project tra.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RB2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: tra +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test.c
