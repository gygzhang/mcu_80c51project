# Keil uVision project 中断键盘.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RB2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: 中断键盘
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key_board.c key_board.h key_board_cfg.h keyboard_test.c
