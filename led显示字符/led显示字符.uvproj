# Keil uVision project led显示字符.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RB2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: led显示字符 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_display.c led_display.h led_display_cfg.h led_test.c
