# Keil uVision project 数字时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RB2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: 数字时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: time_clock.c time_clock_cfg.h time_clock.h time_clock_test.c
    ../led显示字符/: led_display.c
    ../键盘/: key_board.c
